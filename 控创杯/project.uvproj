# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../15-2 直流电机调速/: Delay.c Delay.h Key.c Key.h main.c Nixie.c Nixie.h Timer0.c Timer0.h
