# Keil uVision project project2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./Objects/: 2_1.c 2_2.c 2_3.c 2_4.c 2_4pwm.c 2_5.c 2_6.c 2_7.c 2_affliated.c Delay.c Delay.h example.c
