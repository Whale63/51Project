# Keil uVision project FakeVidio_CatDance.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: FakeVidio_CatDance +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./Objects/: buzzer_music.c Delay.c Delay.h buzzer_music.h main.c tft_cat.c tft_cat.h
