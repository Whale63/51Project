# Keil uVision project CatDance.uvprojx, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: CatDance +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c tft_lcd.c cat_animation.c music.c delay.c
