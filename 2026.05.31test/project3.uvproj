# Keil uVision project project3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 guan.c
    ./Objects/: 3_1.c 3_2.c 3_3.c 3_4.c 3_5.c 3_6.c 3_7.c Delay.c Delay.h
